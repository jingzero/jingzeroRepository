# Keil uVision project HID.uvproj, settings and files
target MCB1700 (ARM-ADS)
  device: LPC1765 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: HID +hex
  c flags: Optim=1
  c include: ..\USBHID;..\UART\Urat
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Files
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Source Files
    ./: usbcfg.h usbcore.c usbdesc.c usbhw.c usbuser.c hiduser.c demo.c uart.c
  group Documentation
    ./: Abstract.txt
